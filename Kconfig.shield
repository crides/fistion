## Kconfig.shield
```kconfig
# Copyright (c) 2020 Pete Johanson
# SPDX-License-Identifier: MIT

config SHIELD_FISTION
	def_bool $(shields_list_contains,fistion)
```
